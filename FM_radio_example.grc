options:
  parameters:
    author: Bradlee Harrison
    generate_options: qt_gui
    id: Custom_Python_Block
    output_language: python
    title: FM_Radio_Example
  states: {}

blocks:
- name: freq_shift
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,3
    label: Frequency Shift
    start: '-1e6'
    step: '1'
    stop: 1e6
    value: '0'
  states: {}
- name: imax
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Maximum Intensity
    start: '-30'
    step: '1'
    stop: '20'
    value: '0'
  states: {}
- name: imin
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Minimum Intensity
    start: '-150'
    step: '1'
    stop: '10'
    value: '-40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.92e6
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '8'
    audio_pass: '16000'
    audio_stop: '20000'
    chan_rate: '384000'
    deviation: '75000'
    gain: '0.3'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_interleaved_char_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: 96_9.dat
    type: byte
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: freq_shift
    sample_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '128'
    type: complex
  states: {}
- name: blocks_sigmf_source_minimal_0
  id: blocks_sigmf_source_minimal
  parameters:
    file: C:\Users\bubba\Downloads\analog_FM_France.sigmf-data
    repeat: 'False'
    type: complex float (fc32_le)
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 480e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"FM Signal"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    int_max: imax
    int_min: imin
    name: '"Filtered FM Signal"'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_waterfall_sink_x_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    int_max: imax
    int_min: imin
    name: '"FM Signal"'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    type: ccc
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', audio_sink_0, '0']
- [blocks_complex_to_interleaved_char_0, '0', blocks_file_sink_1, '0']
- [blocks_freqshift_cc_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_interleaved_char_0, '0']
- [blocks_sigmf_source_minimal_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_sigmf_source_minimal_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_sigmf_source_minimal_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_sigmf_source_minimal_0, '0', qtgui_waterfall_sink_x_1_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_1, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_fm_demod_cf_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
